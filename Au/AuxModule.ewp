# IAR project AuxModule.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21E16A Atmel ATSAMR21E16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMR21_XPLAINED_PRO; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; PHY_AT86RF233
  ICCARM.CCIncludePath2: sam0/drivers/port; sam0/drivers/system/clock/clock_samd21_r21_da_ha1; sam0/drivers/system/interrupt/system_interrupt_samr21; sam0/drivers/extint/extint_sam_d_r_h; sam0/utils/preprocessor; sam0/utils/cmsis/samr21/source; thirdparty/wireless/services/sal/inc; common2/services/delay; sam0/drivers/sercom/spi; thirdparty/wireless/services/trx_access; sam0/utils; sam0/drivers/sercom; sam0/drivers/system/power; sam0/boards; sam0/drivers/sercom/usart; thirdparty/wireless/services/common_hw_timer/sam0; common/services/serial; thirdparty/wireless; sam0/drivers/system/reset/reset_sam_d_r_h; common/utils; sam0/drivers/system/interrupt; thirdparty/wireless/avr2130_lwmesh/source/nwk/inc; sam0/utils/stdio/stdio_serial; thirdparty/wireless/avr2130_lwmesh/source/sys/inc; thirdparty/wireless/services/common_hw_timer; thirdparty/wireless/addons/sio2host/uart; common2/services/delay; common2/services/delay/sam0; sam0/boards/samr21_xplained_pro; sam0/utils/cmsis/samr21/include; sam0/drivers/system/power/power_sam_d_r_h; sam0/drivers/tc/tc_sam_d_r_h; thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc; common/boards; sam0/drivers/system/pinmux; sam0/drivers/system; sam0/drivers/extint; sam0/drivers/tc_; sam0/drivers/tcc_; sam0/drivers/adc_; sam0/drivers/system/reset; sam0/utils/header_files; thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer; sam0/drivers/system/clock; thirdparty/CMSIS/include; thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro; thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro/iar; common/services/serial/sam0_uart; thirdparty/wireless/services/nvm; lzwl/CRC; lzwl/device; lzwl/eemflash; lzwl/FactoryTest; lzwl/function; lzwl/io_define; lzwl/IRQ; lzwl/protocol; lzwl/RF; lzwl/SleepTimer; lzwl/QMA7981; sam0\drivers\wdt; lzwl\DES
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AuxModule.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    lzwl/: main.c main.h
  group common/boards
    common/boards/: board.h
  group common/services/serial
    common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    common/services/serial/sam0_uart/: usart_serial.h
  group common/utils
    common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common2/services/delay
    common2/services/delay/: delay.h
  group common2/services/delay/sam0
    common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group LZWL/CRC
    lzwl/CRC/: CRC.c crc.h
  group LZWL/device
    lzwl/device/: auxdevice.h device.h
  group LZWL/eemflash
    lzwl/eemflash/: eemFlash.c eemFlash.h
  group LZWL/encry
    lzwl/DES/: des.c des.h sha256.c sha256.h
  group LZWL/io_define
    lzwl/io_define/: io_define.h
  group LZWL/IRQ
    lzwl/IRQ/: irq.c irq.h
  group LZWL/Protocol
    lzwl/protocol/: ldsw20.c ldsw20.h ldsw20ofaux.c ldsw20ofaux.h
  group LZWL/RF
    lzwl/RF/: ldsw20rf.c ldsw20rf.h
  group sam0/boards/samr21_xplained_pro
    sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/drivers/adc_
    sam0/drivers/adc_/: adc.c adc.h adc_feature.h
  group sam0/drivers/extint
    sam0/drivers/extint/: extint.h extint_callback.c extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/nvm
    sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/drivers/port
    sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    sam0/drivers/sercom/: sercom.c sercom.h sercom_interrupt.c sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/usart
    sam0/drivers/sercom/usart/: usart.c usart.h usart_interrupt.c usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/system
    sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c clock_config_check.h clock_feature.h gclk.c
  group sam0/drivers/system/interrupt
    sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/tc_
    sam0/drivers/tc_/: tc.c tc.h tc_interrupt.c tc_interrupt.h
  group sam0/drivers/tcc_
    sam0/drivers/tcc_/: tcc.c tcc.h tcc_callback.c tcc_callback.h
  group sam0/drivers/wdt
    sam0/drivers/wdt/: qs_wdt_basic.h wdt.c wdt.h
  group sam0/utils
    sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/include
    sam0/utils/cmsis/samr21/include/: samr21.h samr21e16a.h samr21e17a.h samr21e18a.h samr21e19a.h samr21g16a.h samr21g17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    sam0/utils/cmsis/samr21/include/component/: ac.h adc.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h mtb.h nvmctrl.h pac.h pm.h port.h rfctrl.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group sam0/utils/cmsis/samr21/include/instance
    sam0/utils/cmsis/samr21/include/instance/: ac.h adc.h dmac.h dsu.h eic.h evsys.h gclk.h mtb.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h rfctrl.h rtc.h sbmatrix.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc3.h tc4.h tc5.h tcc0.h tcc1.h tcc2.h usb.h wdt.h
  group sam0/utils/cmsis/samr21/include/pio
    sam0/utils/cmsis/samr21/include/pio/: samr21e16a.h samr21e17a.h samr21e18a.h samr21e19a.h samr21g16a.h samr21g17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/source
    sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/header_files
    sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    sam0/utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam0/utils/stdio
    sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group thirdparty/CMSIS/include
    thirdparty/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group thirdparty/wireless/addons/sio2host/uart
    thirdparty/wireless/addons/sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer
    thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/: conf_trx_access.h config.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro
    thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro/: conf_board.h conf_clocks.h conf_extint.h conf_hw_timer.h conf_sio2host.h conf_sleepmgr.h conf_spi.h
  group thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro/iar
    thirdparty/wireless/avr2130_lwmesh/apps/PeertoPeer/samr21_xplained_pro/iar/: asf.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    thirdparty/wireless/avr2130_lwmesh/source/nwk/inc/: nwk.h nwkCommand.h nwkDataReq.h nwkFrame.h nwkGroup.h nwkRoute.h nwkRouteDiscovery.h nwkRx.h nwkSecurity.h nwkTx.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    thirdparty/wireless/avr2130_lwmesh/source/nwk/src/: nwk.c nwkDataReq.c nwkFrame.c nwkGroup.c nwkRoute.c nwkRouteDiscovery.c nwkRx.c nwkSecurity.c nwkTx.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc
    thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc/: at86rf233.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src
    thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    thirdparty/wireless/avr2130_lwmesh/source/sys/inc/: sys.h sysConfig.h sysEncrypt.h sysTimer.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    thirdparty/wireless/avr2130_lwmesh/source/sys/src/: sys.c sysEncrypt.c sysTimer.c
  group thirdparty/wireless/services/common_hw_timer
    thirdparty/wireless/services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/san0
    thirdparty/wireless/services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/san0/lib
    thirdparty/wireless/services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/nvm
    thirdparty/wireless/services/nvm/: common_nvm.h nvm.h
  group thirdparty/wireless/services/nvm/sam0
    thirdparty/wireless/services/nvm/sam0/: sam_nvm.c
  group thirdparty/wireless/services/nvm/sam0/module_config
    thirdparty/wireless/services/nvm/sam0/module_config/: conf_nvm.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    thirdparty/wireless/services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    thirdparty/wireless/services/sal/inc/: sal.h sal_generic.h sal_types.h
  group thirdparty/wireless/services/trx_access
    thirdparty/wireless/services/trx_access/: trx_access.c trx_access.h
